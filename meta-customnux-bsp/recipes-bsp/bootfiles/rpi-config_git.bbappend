ENABLE_UART = "1"
VC4GRAPHICS = "0"
