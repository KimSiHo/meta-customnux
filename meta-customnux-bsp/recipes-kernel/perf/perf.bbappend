EXTRA_OEMAKE:append = " NO_LIBTRACEEVENT=1 NO_LIBCRYPTO=1 NO_LIBPYTHON=1"
