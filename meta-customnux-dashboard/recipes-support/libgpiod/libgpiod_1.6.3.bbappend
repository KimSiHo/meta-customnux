PACKAGECONFIG += "python3"

FILES:${PN} += " \
    ${PYTHON_SITEPACKAGES_DIR} \
"
