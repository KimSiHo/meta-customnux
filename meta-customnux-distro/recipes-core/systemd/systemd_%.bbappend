PACKAGECONFIG:remove = "resolved nss-resolve"
